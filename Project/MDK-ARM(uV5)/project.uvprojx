# Keil uVision project project.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx,USE_FULL_LL_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_HAL_Driver\Inc;..\..\Libraries\STM32F4xx_HAL_Driver\Src\Legacy;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_beep.c bsp_timer.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_fmc_ad7606.c
  group App
    ../../User/app/src/: DataSample.c Disp.c Modbus_slave.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group HAL_Driver
    ../../User/bsp/: stm32f4xx_hal_conf.h
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
